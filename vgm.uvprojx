# Keil uVision project vgm.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: vgm +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  group Source Group 1
    ./Src/: main.c gpio.c gpio.h timer.c timer.h radio.c radio.h uart.c uart.h main.h spi.c spi.h adc.c adc.h
software components: CMSIS:CORE 5.4.0, Device:Startup 8.35.0, Device:StartupConfig 8.35.0, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_saadc 4.0.0-2.alpha, nRF_Drivers:nrf_spi 4.0.0-2.alpha, nRF_Drivers:nrf_timer 4.0.0-2.alpha, nRF_Drivers:nrf_uart 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha
